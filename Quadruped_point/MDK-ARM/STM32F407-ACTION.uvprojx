# Keil uVision project STM32F407-ACTION.uvprojx, settings and files
target ACTION (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407-ACTION +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\startup;..\Action_User;..\uCOS-ii\Port;..\uCOS-ii\Source;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Action_User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../Action_User/: main.c task.c stm32f4xx_it.c timer.c gpio.c elmo.c usart.c can.c moveBase.c pps.c sensor.c vloop.c lift.c light.c cloudplatform.c pid.c dataProcess.c init.c errorHand.c distanceAdjust.c dataOut.c balance.c module_BLUE.c module_RED.c point.c dma.c switch.c
  group CMSIS
    ../Libraries/CMSIS/: system_stm32f4xx.c
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f4xx.s
  group uCOS-II/Port
    ../uCOS-ii/Port/: os_cpu_c.c os_cpu.h os_cpu_a.asm os_dbg.c
  group uCOS-II/Source
    ../uCOS-ii/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II/Config
    ../uCOS-ii/Source/: OS_AppHooks.c os_cfg.h
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_adc.c stm32f4xx_flash.c stm32f4xx_rng.c
  group Doc
    ./: Readme.txt
